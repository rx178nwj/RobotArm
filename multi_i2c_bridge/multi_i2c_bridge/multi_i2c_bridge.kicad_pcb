# Repository rx178nwj/RobotArm

## KiCad design multi_i2c_bridge/multi_i2c_bridge/multi_i2c_bridge.kicad_pcb

Parts:
C17, C18, C19: 10uF; C_0805_2012Metric
C26: 1uF; C_0603_1608Metric
C27: 0.1uF; C_0603_1608Metric
D7: CHU20S30; D_SOD-323_HandSoldering
J1: HOST_I2C; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J2: Conn_01x02; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J3: SENSOR_CH0; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical
J4: SENSOR_CH1; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical
J5: SENSOR_CH2; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical
J6: SENSOR_CH3; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical
J7: SENSOR_CH4; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical
J8: SENSOR_CH5; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
LED1, LED2: STAT(GRN); LED_0603_1608Metric
Q2: DMG3415; SOT-23
R2, R18, R19, R20, R22, R24, R25: 10k; R_0603_1608Metric
R9, R10: 4.7k; R_0603_1608Metric
R12, R13, R14, R15, R16, R17, R27, R28, R29, R30, R31, R32: 2.2k; R_0603_1608Metric
R21, R26: 1k; R_0603_1608Metric
R23: 100k; R_0603_1608Metric
U1: TCA9548A_BreakoutBoard
U2: WisdPi_Tiny_RP2040
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: Main_Board

Connections:
5V_IN: C17.1, C26.1, C27.1, D7.1 (K), Q2.2 (S), U3.3 (VI)
+3.3V: C18.1, C19.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, JP1.2 (B), R2.1, R9.1, R10.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, U1.1 (VIN), U3.2 (VO)
DIR0: J3.5, R18.1, U2.6 (GP5)
DIR1: J4.5, R19.1, U2.7 (GP6)
DIR2: J5.5, R20.1, U2.8 (GP7)
DIR3: J6.5, R22.1, U2.9 (GP8)
DIR4: J7.5, R24.1, U2.10 (GP9)
DIR5: J8.5, R25.1, U2.11 (GP10)
GND: C17.2, C18.2, C19.2, C26.2, C27.2, J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, LED1.1 (K), LED2.1 (K), R18.2, R19.2, R20.2, R22.2, R23.1, R24.2, R25.2, U1.2 (GND), U1.6 (A0), U1.7 (A1), U1.8 (A2), U2.28 (GND), U3.1 (GND)
HOST_3.3V: J1.1, JP1.1 (A)
HOST_5V: J2.1, Q2.3 (D)
I2C0_SCL_HOST: J1.4, U2.2 (GP1)
I2C0_SDA_HOST: J1.3, U2.1 (GP0)
I2C1_SCL: R10.2, U1.4 (SCL), U2.4 (GP3)
I2C1_SDA: R9.2, U1.3 (SDA), U2.3 (GP2)
I2C_CH0_SCL: J3.3, R13.2, U1.10 (SC0)
I2C_CH0_SDA: J3.4, R12.2, U1.9 (SD0)
I2C_CH1_SCL: J4.3, R15.2, U1.12 (SC1)
I2C_CH1_SDA: J4.4, R14.2, U1.11 (SD1)
I2C_CH2_SCL: J5.3, R17.2, U1.14 (SC2)
I2C_CH2_SDA: J5.4, R16.2, U1.13 (SD2)
I2C_CH3_SCL: J6.3, R28.2, U1.16 (SC3)
I2C_CH3_SDA: J6.4, R27.2, U1.15 (SD3)
I2C_CH4_SCL: J7.3, R30.2, U1.18 (SC4)
I2C_CH4_SDA: J7.4, R29.2, U1.17 (SD4)
I2C_CH5_SCL: J8.3, R32.2, U1.19 (SD5)
I2C_CH5_SDA: J8.4, R31.2, U1.20 (SC5)
LED_STAT1: R21.1, U2.26 (GP25)
LED_STAT2: R26.1, U2.25 (GP24)
MUX_RST_N: R2.2, U1.5 (RST), U2.5 (GP4)
unnamed: LED1.2 (A), R21.2
unnamed: LED2.2 (A), R26.2
VBUS: D7.2 (A), Q2.1 (G), R23.2, U2.29 (VBUS)

Notes on the sheet:
センサ接続コネクタ (ch3-5)
センサ接続コネクタ (ch0-2)
下流プルアップ: mux上流4.7k / 各chセグメント2.2k (10k不可: design_spec §6.2 tr違反)
WisdPi Tiny RP2040 オンボード: GP25=Blue LED / GP27=Yellow LED / GP28=Red LED / GP29=WS281
DIRプルダウン(ブート中フロート防止, design_spec §6.4)

Board: 2 copper layers, 60.0 x 60.0 mm, 46 parts (1 on the bottom side), 33 nets.

## KiCad design multi_i2c_bridge/schematics/multi_i2c_bridge.kicad_pcb

File multi_i2c_bridge/schematics/README.md:

# マルチI2Cブリッジ 制御回路（KiCad）

[design_spec.md](../docs/design_spec.md) v0.1 §6（電気仕様）および
[i2c_architecture.md](../docs/i2c_architecture.md) §11（確定事項）に基づく回路図・基板。

- `multi_i2c_bridge.kicad_pro` / `multi_i2c_bridge.kicad_sch` / `multi_i2c_bridge.kicad_pcb` — KiCad 8 以降で開けます
- シンボル・フットプリントは全てファイルに埋め込み済み（外部ライブラリ不要）
- `generate_schematic.py` — 回路図の生成スクリプト（再生成用）

## PCB（50×50mm・2層）

- 外形 50×50mm、M2.5取付穴×4、両面GNDベタゾーン（KiCad上で `B` キーで再充填）
- **配線済み（自作オートルータ`route_pcb.py`による全自動配線）**
  - 全39ネット配線完了・セグメント626本・ビア100個（うちGNDステッチ43個+スタブ39本）
  - 設計ルール: 信号0.2mm / 電源(3V3系)0.25mm / クリアランス0.15mm / ビア0.6/0.3mm
  - GND: 配線せず両面ベタ+各SMD GNDパッド脇ビア接続（RP2040 EPにビア4個）
  - RP2040西側GPIO 8本は0.4→0.9mmピッチの階段状ファンアウトでB面へ引出し
  - `verify_pcb.py`（独立検証）で接続性=分断ネット0・クリアランス違反0を確認済み
  - **KiCad上でゾーン充填(`B`)→DRC実行を必ず行うこと**（ベタとの最終整合確認）
- パッケージ方針（2026-07-10 指定）:
  - RP2040関連コンデンサ（デカップリングC1-C12・水晶C13/C14）= **0402**
  - LED・抵抗・その他チップ = **0603**（電源ダイオードD1/D2のみ電流容量のためSMA）
  - センサハーネス用コネクタ J2-J4 = **JST PH（2.0mmピッチ, B5B-PH-K）**
  - 上位コネクタ J1 = JST XH 4P（指定はセンサ側のみのため現状XH。PH統一なら要指示）
- 配置概要: 上辺=USB+電源(LDO)、左辺=J1上位コネクタ、中央=RP2040+デカップリングリング、
  左中=フラッシュ+水晶、右=TCA9548A+プルアップ列+J2-J4、下辺=RESET/BOOTボタン+SWD
- ⚠ フットプリントは自動生成（寸法は標準値ベース）。**USB Micro-B・JST PH/XH・TL3342は
  発注前に実部品のデータシートと照合すること**

## 回路構成

| ブロック | 部品 | 仕様上の根拠 |
|---------|------|--------------|
| ブリッジMCU | U1 RP2040 (QFN-56) | design_spec §7 で確定 |
| QSPIフラッシュ | U2 W25Q128JVSIQ | RP2040は外部Flash必須（§6.3） |
| クロック | Y1 12MHz (ABM8) + 27pF×2 + 1kΩ | RP2040 Hardware design guide 準拠 |
| I2C mux | U3 TCA9548APWR, アドレス0x70 (A0-A2=GND) | §3/§4 |
| mux RESET | GP4 駆動 + 10kプルアップ (R11) | §6.3 |
| 角度センサ | U5-U7 AS5600 ×3（別基板・参考記載） | VDD5V-VDD3V3短絡=3.3V動作必須、100nF近傍、OTP不使用のため10µF省略（§6.1） |
| DIR制御 | GP5/6/7 → 各ch独立、10kプルダウン (R18-20) | §6.4（ブート中フロート防止） |
| 電源 | USB VBUS / J1の5V をショットキーOR → AP2112K-3.3 | 全系3.3V統一（§6.1） |
| 書込/デバッグ | USB Micro-B (BOOTSEL) + SWDヘッダ + RESET/BOOTボタン | — |
| 状態LED | GP25 → LED1 | — |

## I2Cプルアップ（design_spec §6.2 の根拠通り）

| バス | 抵抗 | 値 |
|------|------|----|
| 上流（Controller⇔RP2040, GP0/GP1） | R7, R8 | 2.2kΩ（ホスト側実装時はDNP） |
| ブリッジ⇔mux（GP2/GP3） | R9, R10 | 4.7kΩ |
| mux各chセグメント（ch0-2） | R12-R17 | 2.2kΩ（10kΩはtr違反リスクで不採用） |

※ AS5600モジュール側にプルアップ実装済みの場合は並列合成値に注意（下がり過ぎ防止のためch側をDNP調整）。

## GPIO割当（design_spec §6.4 の通り）

GP0/1=上流I2C0、GP2/3=下流I2C1、GP4=mux RESET、GP5-7=DIR ch0-2、GP25=状態LED。
GP8-24/26-29は未使用（将来のPIO並列I2C移行用に6本予約可、i2c_architecture §5.6）。

## コネクタ

| Ref | 用途 | ピン配列 |
|-----|------|---------|
| J1 | 上位コントローラ | 1:5V_IN 2:GND 3:SCL 4:SDA（JST-XH 4P） |
| J2-J4 | センサch0-2 | 1:3V3 2:GND 3:SCL 4:SDA 5:DIR（JST-XH 5P） |
| J8 | SWD | 1:SWCLK 2:GND 3:SWDIO |
| J9 | USB Micro-B | ファーム書込（BOOTSEL）・給電 |

## 設計上の仮定（要確認）

1. **電源**: 仕様書は「全系3.3V」だが供給元の記載がないため、**J1またはUSBから5Vを受けて基板上LDOで3.3V生成**とした。上位から3.3V直給電にする場合はD2/U4をバイパスする改版が必要。
2. 上流レベルシフタ用フットプリント予約（i2c_architecture §11.1推奨）は未実装。5V系ホスト対応が必要になった時点で追加。
3. 割込み予約GPIO配線（i2c_architecture §7、任意）は未実装。

## 次ステップ

- [ ] KiCad上でERC/DRC実行・目視レビュー（レジスタマップ確定後の回路変更有無を確認）
- [ ] KiCadでGNDゾーン充填（`B`）→ DRC → 3Dビューで最終確認
- [ ] AS5600配置・ケーブル長の確定 → chプルアップ値の最終調整（400kHz成立確認）
- [ ] USB Micro-B / JST PH / TL3342 の実部品フットプリント照合

Board: 2 copper layers, 50.0 x 50.0 mm, 62 parts (0 on the bottom side), 40 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C10, C11, C12: 100nF; C_0402
C9: 1uF; C_0402
C13, C14: 27pF; C_0402
C15, C16: 100nF; C_0603
C17, C18, C19: 10uF; C_0805
D1, D2: SS14; D_SMA
H1, H2, H3, H4: M2.5; HOLE
J1: HOST_I2C; XH4
J2: SENSOR_CH0; PH5
J3: SENSOR_CH1; PH5
J4: SENSOR_CH2; PH5
J8: SWD; HDR3
J9: USB_Micro-B; USB_MICRO
LED1: STAT(GRN); C_0603
LED2: PWR(GRN); C_0603
R1, R2: 27R; R_0603
R3, R6, R21, R22: 1k; R_0603
R4, R5, R11, R18, R19, R20: 10k; R_0603
R7, R8, R12, R13, R14, R15, R16, R17: 2.2k; R_0603
R9, R10: 4.7k; R_0603
SW1: RESET; SW
SW2: BOOT; SW
U1: RP2040; QFN56
U2: W25Q128JVSIQ; SOIC8W
U3: TCA9548APWR; TSSOP24
U4: AP2112K-3.3; SOT235
Y1: ABM8-272-T3 12MHz; XTAL3225

Connections:
3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C10.1, C11.1, C12.1, C15.1, C16.1, C18.1, C19.1, J2.1, J3.1, J4.1, LED2.2, R4.1, R5.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, U1.1, U1.10, U1.22, U1.33, U1.42, U1.43, U1.44, U1.48, U1.49, U2.8, U3.24, U4.5
5V_IN: C17.1, D1.1, D2.1, U4.1, U4.3
BOOTSEL: R6.2, SW2.1
DIR0: J2.5, R18.1, U1.7
DIR1: J3.5, R19.1, U1.8
DIR2: J4.5, R20.1, U1.9
DVDD_1V1: C7.1, C8.1, C9.1, U1.23, U1.45, U1.50
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, J1.2, J2.2, J3.2, J4.2, J8.2, J9.5, J9.6, LED1.1, R18.2, R19.2, R20.2, R22.2, SW1.2, SW2.2, U1.19, U1.57, U2.4, U3.1, U3.2, U3.12, U3.21, U4.2, Y1.2, Y1.4
HOST_5V: D2.2, J1.1
I2C0_SCL_HOST: J1.3, R8.2, U1.3
I2C0_SDA_HOST: J1.4, R7.2, U1.2
I2C1_SCL: R10.2, U1.5, U3.22
I2C1_SDA: R9.2, U1.4, U3.23
I2C_CH0_SCL: J2.3, R13.2, U3.5
I2C_CH0_SDA: J2.4, R12.2, U3.4
I2C_CH1_SCL: J3.3, R15.2, U3.7
I2C_CH1_SDA: J3.4, R14.2, U3.6
I2C_CH2_SCL: J4.3, R17.2, U3.9
I2C_CH2_SDA: J4.4, R16.2, U3.8
LED_STAT: R21.1, U1.37
MUX_RST_N: R11.2, U1.6, U3.3
unnamed: LED1.2, R21.2
unnamed: LED2.1, R22.1
QSPI_SCLK: U1.52, U2.6
QSPI_SD0: U1.53, U2.5
QSPI_SD1: U1.55, U2.2
QSPI_SD2: U1.54, U2.3
QSPI_SD3: U1.51, U2.7
QSPI_SS_N: R5.2, R6.1, U1.56, U2.1
RUN: R4.2, SW1.1, U1.26
SWCLK: J8.1, U1.24
SWDIO: J8.3, U1.25
USB_DM: R1.2, U1.46
USB_DM_J: J9.2, R1.1
USB_DP: R2.2, U1.47
USB_DP_J: J9.3, R2.1
VBUS: D1.2, J9.1
XIN: C13.1, U1.20, Y1.1
XOUT: R3.1, U1.21
XOUT_X: C14.1, R3.2, Y1.3

## Code that names these connections

File multi_i2c_bridge/schematics/generate_schematic.py (part):

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add_nc(*p["4"])

pd1 = place_v2("bridge:D_Schottky", "D1", "SS14", 75, 48, D_offs, "VBUS", "5V_IN", "Diode_SMD:D_SMA")
pd2 = place_v2("bridge:D_Schottky", "D2", "SS14", 88, 48, D_offs, "HOST_5V", "5V_IN", "Diode_SMD:D_SMA")

p = place("bridge:AP2112K-3.3", "U4", "AP2112K-3.3", 112, 50, LDO_offs, "Package_TO_SOT_SMD:SOT-23-5")
x, y = p["1"]; add_glabel("5V_IN", x, y, 180)
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add_text("12MHz水晶 (CL=10pF級, 27pF+1k: RP2040 HW design guide)", 25, 144, 1.6, True)
p = place("bridge:ABM8-12MHz", "Y1", "ABM8-272-T3 12MHz", 45, 150, XTAL_offs,
          "Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm")
x, y = p["1"]; add_glabel("XIN", x, y, 180)
x, y = p["2"]; add_glabel("GND", x, y, 180)
x, y = p["3"]; add_glabel("XOUT_X", x, y, 0)
x, y = p["4"]; add_glabel("GND", x, y, 0)
place_v2("bridge:C", "C13", "27pF", 35, 180, C_offs, "XIN", "GND", C_FP_0402)
place_v2("bridge:C", "C14", "27pF", 45, 180, C_offs, "XOUT_X", "GND", C_FP_0402)
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